# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Source\STM32F10x_StdPeriph_Driver\inc;.\Source\CMSIS\CoreSupport;.\Source\CMSIS\DeviceSupport;.\Source\CMSIS\DeviceSupport\ST;.\Source\CMSIS\DeviceSupport\ST\STM32F10x;.\Source\CMSIS\DeviceSupport\ST\STM32F10x\startup;.\Source\HARDWORK\LED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./Source/User/: main.c
  group CMSIS
    ./Source/CMSIS/CoreSupport/: core_cm3.c
    ./Source/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Source/CMSIS/DeviceSupport/ST/STM32F10x/startup/: startup_stm32f10x_hd.s
  group Drives
    ./Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group HARDWORK
    ./Source/HARDWORK/LED/: LED.c
software components: CMSIS:CORE 5.1.1
